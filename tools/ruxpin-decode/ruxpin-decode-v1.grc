options:
  parameters:
    generate_options: qt_gui
    id: u16test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: aud_samp_pad
  id: variable
  parameters:
    value: '142'
  states: {}
- name: field_1_start
  id: variable
  parameters:
    value: '23'
  states: {}
- name: field_2_start
  id: variable
  parameters:
    value: '23'
  states: {}
- name: fin_decimation
  id: variable
  parameters:
    value: '21'
  states: {}
- name: num_snd_samples
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '14318182'
  states: {}
- name: sound_lines_1
  id: variable
  parameters:
    value: '234'
  states: {}
- name: sound_lines_2
  id: variable
  parameters:
    value: '233'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: num_snd_samples
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '65536'
    type: float
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: round((samp_rate / (478660 / ((sound_lines_1 + sound_lines_2) * num_snd_samples)))/fin_decimation)
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-.45'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: variable_qtgui_range_0
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: vhsdecode-source.tbc
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '255'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
    vlen: '910'
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
    vlen: '910'
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
    vlen: '910'
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: short
    vlen: '910'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '255'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (field_1_start,sound_lines_1,263-(field_1_start+sound_lines_1))
    num_outputs: '3'
    type: short
    vlen: '910'
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (aud_samp_pad, num_snd_samples, 910-(aud_samp_pad+num_snd_samples))
    num_outputs: '3'
    type: short
  states: {}
- name: blocks_stream_demux_0_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (aud_samp_pad, num_snd_samples, 910-(aud_samp_pad+num_snd_samples))
    num_outputs: '3'
    type: short
  states: {}
- name: blocks_stream_demux_0_1
  id: blocks_stream_demux
  parameters:
    lengths: (field_2_start,sound_lines_2,263-(field_2_start+sound_lines_2))
    num_outputs: '3'
    type: short
    vlen: '910'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (sound_lines_1*num_snd_samples,sound_lines_2*num_snd_samples)
    type: short
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: short
    vlen: (263*910)
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: (263*910)
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*2
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '263'
    type: short
    vlen: '910'
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '263'
    type: short
    vlen: '910'
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '910'
    type: short
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '910'
    type: short
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: tv_teddy_decodedaudio.wav
    format: FORMAT_WAV
    samp_rate: round((samp_rate / (478660 / ((sound_lines_1 + sound_lines_2) * num_snd_samples)))/fin_decimation)
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    gain: '1'
    interp: '1'
    samp_rate: (samp_rate / (478660 / ((sound_lines_1 + sound_lines_2) * num_snd_samples)))/fin_decimation
    type: interp_fir_filter_fff
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / (478660 / ((sound_lines_1 + sound_lines_2) * num_snd_samples))
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    ymax: '6555'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: after filter
    size: '1024'
    srate: round((samp_rate / (478660 / ((sound_lines_1 + sound_lines_2) * num_snd_samples)))/fin_decimation)
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: before filter
    size: '1024'
    srate: '10000'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: fin_decimation
    interp: '1'
    type: fff
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: 526*2
    display_width: 910*2
    fps: '0'
    height: '526'
    type: short
    width: '910'
  states: {}
- name: video_sdl_sink_0_0
  id: video_sdl_sink
  parameters:
    display_height: (sound_lines_1 + sound_lines_2)*2
    display_width: num_snd_samples*4
    fps: '0'
    height: sound_lines_1 + sound_lines_2
    type: short
    width: num_snd_samples
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_rail_ff_1, '0', blocks_float_to_short_0, '0']
- [analog_rail_ff_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_divide_xx_0, '0', analog_rail_ff_1, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_const_vxx_1, '0']
- [blocks_short_to_float_1, '0', blocks_add_xx_1, '1']
- [blocks_short_to_float_1, '0', blocks_delay_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_demux_0, '1', blocks_vector_to_stream_1_0, '0']
- [blocks_stream_demux_0, '2', blocks_null_sink_0_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0_0, '1', blocks_stream_mux_0, '0']
- [blocks_stream_demux_0_0, '2', blocks_null_sink_1_0, '0']
- [blocks_stream_demux_0_0_0, '0', blocks_null_sink_1_1, '0']
- [blocks_stream_demux_0_0_0, '1', blocks_stream_mux_0, '1']
- [blocks_stream_demux_0_0_0, '2', blocks_null_sink_1_0_0, '0']
- [blocks_stream_demux_0_1, '0', blocks_null_sink_0_1, '0']
- [blocks_stream_demux_0_1, '1', blocks_vector_to_stream_1_0_0, '0']
- [blocks_stream_demux_0_1, '2', blocks_null_sink_0_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_short_to_float_1, '0']
- [blocks_stream_mux_0, '0', video_sdl_sink_0_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_vector_to_stream_0_1, '0']
- [blocks_stream_to_streams_0, '1', blocks_vector_to_stream_0_1_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_deinterleave_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_stream_demux_0, '0']
- [blocks_vector_to_stream_0_1_0, '0', blocks_stream_demux_0_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_stream_demux_0_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_stream_demux_0_0_0, '0']
- [high_pass_filter_0, '0', audio_sink_0, '0']
- [high_pass_filter_0, '0', blocks_null_sink_2, '0']
- [high_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', high_pass_filter_0, '0']

metadata:
  file_format: 1
